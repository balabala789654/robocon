# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ..\Driver\CORE;..\Driver\FWLIB\inc;..\FreeRTOS\FreeRTOS_v2\FreeRTOSv202212.01\FreeRTOS\Source\include;..\FreeRTOS\FreeRTOS_v2\FreeRTOSv202212.01\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\HARDWARE\inc;..\USER\SYSTEM\inc;..\Rabbit\inc;..\USER\algorithm;..\USER\APP;..\Driver\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c
  group Drive
    ../Driver/CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Lib
    ../Driver/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../USER/SYSTEM/src/: delay.c sys.c
    ../USER/APP/: motor_feedback.c remote_control.c
    ../USER/algorithm/: pid.c dead_zone.c Low_pass.c
  group Hardware
    ../HARDWARE/src/: can.c gpio.c IIC.c spi.c timer.c usart.c adc.c
  group Freertos
    ../FreeRTOS/FreeRTOS_v2/FreeRTOSv202212.01/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/FreeRTOS_v2/FreeRTOSv202212.01/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/FreeRTOS_v2/FreeRTOSv202212.01/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Rabbit
    ../Rabbit/src/: chassis.c pick_up.c shoot.c status.c rabbit.c
  group Dsp
    ../Driver/CMSIS/DSP/Source/BasicMathFunctions/: arm_abs_f32.c arm_add_f32.c arm_mult_f32.c arm_sub_f32.c
    ../Driver/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../Driver/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
